# IAR project DriverLib.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F5133.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: Debug_Main.c Driver_Alarm.c Driver_Button.c Driver_Buzzer.c Driver_DetBusy.c Driver_Flash.c Driver_IO.c Driver_Led.c Driver_RF.c Driver_RFID.c Driver_Routin.c Driver_RTC.c Driver_S35390.s43 Driver_SysCLK.c Driver_Uart.c Driver_VoiceLevel.c Driver_WDT.c
