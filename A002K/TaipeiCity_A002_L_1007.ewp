# IAR project TaipeiCity_A002_L_1007.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xmfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    DriverLib/Debug/Exe/: DriverLib.r43
    ./: main.c SOP.c SystemConfig.c
  group Cti
    Cti/: Cti.c VoiceControl.c
  group Flow
    Flow/: Flow_Alarm.c Flow_HealthData.c Flow_main.c Flow_NormalStandby.c Flow_Service.c Flow_StartLine.c Flow_SystemCheck.c Flow_SystemReport.c
    Tentel/: RangBuffer.c
  group MeasureDev
    MeasureDev/: MeasureDev.c
  group MeasureDev/Dongle
    MeasureDev/DongleLib/: DongleLib.c
  group MeasureDev/TaiDoc
    MeasureDev/TaiDoc/: TaiDoc.c
  group TENTEL
    Tentel/: Tentel.c
