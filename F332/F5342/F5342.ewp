# IAR project F5342.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsff.h
  General.OGChipSelectMenu: MSP430F5342 MSP430F5342
  General.GStackSize2: 1024
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\; ..\Lib\CTS; ..\Lib\F5xx_F6xx_Core_Lib; ..\Lib\FatFs; ..\Lib\F5342_Driver; 
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5342.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: ..\; ..\CTS; ..\F5xx_F6xx_Core_Lib; ..\FatFs; ..\MSP-EXP430F5529_HAL; ..\USB; ..\USB\USB_API; ..\USB\USB_API\USB_CDC_API; ..\USB\USB_API\USB_Common; ..\USB\USB_API\USB_HID_API; ..\USB\USB_API\USB_MSC_API; ..\USB\USB_config; ..\USB\USB_User; ..\UserExperienceDemo; ..\UserExperienceDemo\Puzzle
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: Main_5342.c
  group F5342
    ./: ADC.c ADC.h Bluetooth.c Bluetooth.h SDCard.c SDCard.h
  group Lib/5342_Driver
    ../Lib/F5342_Driver/: HAL_Board.c HAL_Board.h HAL_Buttons.c HAL_Buttons.h HAL_SDCard.c HAL_SDCard.h HAL_Uart.c HAL_Uart.h
  group Lib/CoreLib
    ../Lib/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group Lib/CTS
    ../Lib/CTS/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h structure.c structure.h
  group Lib/FatFS
    ../Lib/FatFs/: diskio.h ff.c ff.h ffconf.h integer.h mmc.c mmc.h
