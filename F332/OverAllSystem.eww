<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\F5310\F5310.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\F5342\F5342.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\F5529\F5529.ewp</path>
  </project>
  <batchBuild/>
</workspace>


