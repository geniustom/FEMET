# IAR project F5310.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5310 MSP430F5310
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\; ..\Lib\CTS; ..\Lib\F5xx_F6xx_Core_Lib; ..\Lib\F5310_Driver; 
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5310.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: F332_CMD.c F332_Lib.c F332_Lib.h Main_5310.c
  group Lib/5310_Driver
    ../Lib/F5310_Driver/: HAL_Board.c HAL_Board.h HAL_Uart.c HAL_Uart.h
  group Lib/CoreLib
    ../Lib/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group Lib/CTS
    ../Lib/CTS/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h structure.c structure.h
